# Keil uVision project ARM Cortex M55 Template BootLoader Jumping.uvprojx, settings and files
target BootLoader Jumping (6240000::V6.24::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\Application\Include;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x18000000 size 0x2800
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\Scatter Loading File\bootloader-jumping.sct
  link misc: --diag_suppress=L6305 --diag_suppress=L6314
  group Drivers/CMSIS/Device
    ../Drivers/CMSIS/Device/Source/: startup_arm_cortex_m55.c
